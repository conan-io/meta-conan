inherit setuptools python-dir
require python-packaging.inc