# This is in the master branch but not on the thud branch
BBCLASSEXTEND += "native"
