inherit setuptools3 python3-dir
require python-patch.inc