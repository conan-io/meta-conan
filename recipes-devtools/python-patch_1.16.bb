inherit setuptools python-dir
require python-patch.inc