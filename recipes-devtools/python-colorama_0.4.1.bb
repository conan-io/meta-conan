inherit setuptools python-dir
require python-colorama.inc