inherit setuptools python-dir
require python-pygments.inc