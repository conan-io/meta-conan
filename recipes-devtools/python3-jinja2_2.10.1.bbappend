# Add missing asyncio requirement

RDEPENDS_${PN} += " \
    ${PYTHON_PN}-asyncio \
"
