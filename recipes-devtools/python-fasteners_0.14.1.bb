inherit setuptools python-dir
require python-fasteners.inc