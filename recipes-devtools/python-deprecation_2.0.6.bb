inherit setuptools python-dir
require python-deprecation.inc