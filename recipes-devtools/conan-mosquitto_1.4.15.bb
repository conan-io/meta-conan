DESCRIPTION = "An open source MQTT broker"
LICENSE = "EPL-1.0"

CONAN_PKG = "mosquitto/1.4.15@bincrafters/stable"
CONAN_REMOTE = "http://35.185.255.93/artifactory/api/conan/conan-yocto"

inherit conan