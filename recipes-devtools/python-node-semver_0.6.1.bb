inherit setuptools python-dir
require python-node-semver.inc