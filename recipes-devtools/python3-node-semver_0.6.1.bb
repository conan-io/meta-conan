inherit setuptools3 python3-dir
require python-node-semver.inc